# Keil uVision project 1343Platform.uvprojx, settings and files
target LPC134x_IFLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1343FBD48 NXP
  pack: Keil.LPC1300_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1343Platform +hex
  BeforeMake: C:\Users\u000706\dflory_workspace\Hardware\1343Platform\Source\Firmware\Prebuild.cmd
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\..\Output\firmware\;..\Common\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source
    ./: usbdesc.c system_LPC13xx.c startup_LPC13xx.s hidadapt.c Main.c SerialPort.c linkserve.cpp slave.cpp linkfuns.c Quadrature.c PWM.c PIDServe.c msgbuff.c seglist.c segmentprocess.c plist.c i2c_1343.c
    ../../Output/Firmware/: slavemll.c
software components: CMSIS:CORE 4.1.0
